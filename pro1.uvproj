# Keil uVision project pro1.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC932A1 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: pro1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.asm reg932.inc
